# Keil uVision project canresolve.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: canresolve +hex
  c flags: Optim=1 wLevel=2
  c include: ..\CMSIS;..\CMSIS\startup;..\FWlib\inc;..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\SYSTEM\crc;..\HARDWARE\UART;..\HARDWARE\CAN;..\HARDWARE\MCP2515;..\User;..\HARDWARE\TIMER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/: stm32f10x_it.c system_stm32f10x.c
    ../CMSIS/startup/: core_cm3.c
  group FWLib
    ../FWlib/src/: misc.c stm32f10x_can.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_dma.c stm32f10x_tim.c
  group STARTUP
    ../CMSIS/startup/: startup_stm32f10x_md.s
  group USER
    ../User/: main.c can_speed.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/UART/: usart2.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/TIMER/: timer.c
  group SYSTERM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/crc/: crc8.c
